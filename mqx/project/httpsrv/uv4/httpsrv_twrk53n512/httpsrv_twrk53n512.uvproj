# Keil uVision project httpsrv_twrk53n512.uvproj, settings and files
target httpsrv Int Flash Debug (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: httpsrv +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../../lib/twrk53n512.uv4/debug/bsp/Generated_Code;../../../../../lib/twrk53n512.uv4/debug/rtcs;../../../../../lib/twrk53n512.uv4/debug/bsp;../../../../../lib/twrk53n512.uv4/debug/psp;../../../../../lib/twrk53n512.uv4/debug/shell;../../../../../lib/twrk53n512.uv4/debug/mfs;../../../../../lib/twrk53n512.uv4/debug;../../../../../rtcs/examples/httpsrv;../../../../../lib/twrk53n512.uv4/debug/bsp/Sources
  asm define: _DEBUG=1
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk53n512.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../lib/twrk53n512.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../../lib/twrk53n512.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group Source
    ../../../../../rtcs/examples/httpsrv/: tfs_data.c config.h httpdsrv.h httpdsrv.c cgi.h cgi.c
  group MQX Libraries
    ../../../../../lib/twrk53n512.uv4/debug/bsp/: bsp.lib
    ../../../../../lib/twrk53n512.uv4/debug/shell/: shell.lib
    ../../../../../lib/twrk53n512.uv4/debug/psp/: psp.lib
    ../../../../../lib/twrk53n512.uv4/release/mfs/: mfs.lib
    ../../../../../lib/twrk53n512.uv4/release/psp/: psp.lib
    ../../../../../lib/twrk53n512.uv4/release/rtcs/: rtcs.lib
    ../../../../../lib/twrk53n512.uv4/debug/rtcs/: rtcs.lib
    ../../../../../lib/twrk53n512.uv4/debug/mfs/: mfs.lib
    ../../../../../lib/twrk53n512.uv4/release/bsp/: bsp.lib
    ../../../../../lib/twrk53n512.uv4/release/shell/: shell.lib
target httpsrv Int Flash Release (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: as above
  output: httpsrv +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ../../../../../lib/twrk53n512.uv4/release/bsp/Sources;../../../../../lib/twrk53n512.uv4/release/shell;../../../../../lib/twrk53n512.uv4/release/psp;../../../../../lib/twrk53n512.uv4/release/mfs;../../../../../lib/twrk53n512.uv4/release/bsp/Generated_Code;../../../../../lib/twrk53n512.uv4/release/bsp;../../../../../rtcs/examples/httpsrv;../../../../../lib/twrk53n512.uv4/release/rtcs;../../../../../lib/twrk53n512.uv4/release
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk53n512.uv4/release/bsp/intflash.scf
  link misc: ../../../../../lib/twrk53n512.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../../lib/twrk53n512.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
